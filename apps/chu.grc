options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: chu
    output_language: python
  states: {}

blocks:
- name: channel_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: chu_freq
  id: variable
  parameters:
    value: '3330000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: samp_rate // 48000
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.4'
    stop: '50'
    value: '10'
  states: {}
- name: mark_tone
  id: variable
  parameters:
    value: '2225'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: space_tone
  id: variable
  parameters:
    value: '2025'
  states: {}
- name: upconverter_lo_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-1'
    reference: '0.02'
    type: float
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '1.8'
    min_freq: '-1.8'
    w: 3.1416 / 500
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: channel_rate / (3.1416*(mark_tone - space_tone))
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(space_tone + mark_tone) / 2'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate / decimation
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: samp_rate / decimation
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: ham_chu_decode_0
  id: ham_chu_decode
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '10'
    gain: '1000'
    samp_rate: samp_rate / 25
    type: fir_filter_ccf
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: chu_freq - offset + upconverter_lo_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '100'
    samp_rate: channel_rate
    sym_rate: '300'
    type: fir_filter_fff
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', band_pass_filter_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_multiply_xx_2, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_2, '1']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_2, '0', low_pass_filter_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', ham_chu_decode_0, '0']
- [low_pass_filter_0, '0', analog_pll_carriertracking_cc_0, '0']
- [low_pass_filter_1, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_1, '0']
- [osmosdr_source_1, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_binary_slicer_fb_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
